# Keil uVision project J1939.uvprojx, settings and files
target J1939 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: J1939 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Apps\inc;..\Peripherals\inc;..\Ucos\CMSIS;..\Ucos\CORE;..\Ucos\FWLIB\inc;..\Ucos\SYSTEM\delay;..\Ucos\SYSTEM\sys;..\Ucos\SYSTEM\usart;..\Ucos\UCOSII\CONFIG;..\Ucos\UCOSII\CORE;..\Ucos\UCOSII\PORT;..\Peripherals
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Apps
    ../Apps/src/: JzCanParse.c JzCanRead.c JzJ1939.c JzParam.c JzParseUser.c JzQueue.c JzRingbuffer.c JzThreadInfo.c JzUartCan.c JzUartParse.c JzUartRead.c JzUartSend.c SystermDefine.c
    ../Apps/: JzAppMain.c
  group Peripherals
    ../Peripherals/src/: Jz_Peripheral_Can.c Jz_Peripheral_Uart.c Jz_Peripheral_Led.c Jz_Peripheral_Timer.c
    ../Peripherals/: JzPeripherals.c
  group OS
    ../Ucos/CMSIS/: stm32f10x_it.c system_stm32f10x.c
    ../Ucos/CORE/: core_cm3.c startup_stm32f10x_md.s
    ../Ucos/UCOSII/CORE/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_core.c os_sem.c os_task.c os_time.c os_tmr.c
    ../Ucos/UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group FWLIB
    ../Ucos/FWLIB/src/: stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTERM
    ../Ucos/SYSTEM/delay/: delay.c
    ../Ucos/SYSTEM/sys/: sys.c
    ../Ucos/SYSTEM/usart/: usart.c
  group Main
    ../: main.c
